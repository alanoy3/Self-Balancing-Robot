# Keil uVision project self-balancing-robot.uvprojx, settings and files
target self-balancing-robot (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: self-balancing-robot
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_HAL_DRIVER,STM32F072xB,MPU6050,EMPL_TARGET_STM32F4
  c include: ../Inc;       ../Drivers/STM32F0xx_HAL_Driver/Inc;       ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;       ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;       ../Drivers/CMSIS/Include;       ..\Src;       ..\Src\printf_&_scanf_override_HAL;       ..\Src\MPU6050\driver\eMPL;       ..\Src\MPU6050\driver\include;       ..\Src\MPU6050\driver\stm32L;       ..\Src\MPU6050\eMPL-hal;       ..\Src\MPU6050\mllite;       ..\Src\MPU6050\mpl;       ..\Src\MPU6050
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_dma.c stm32f0xx_hal_pwr.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_rcc.c stm32f0xx_hal_gpio.c stm32f0xx_hal_cortex.c stm32f0xx_hal.c stm32f0xx_hal_i2c_ex.c
  group MPU6050
    ../Src/MPU6050/: MPU6050_set_Init.c MPU6050_get_data.c
    ../Src/MPU6050/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../Src/MPU6050/driver/stm32L/: log_stm32.c
    ../Src/MPU6050/eMPL-hal/: eMPL_outputs.c
    ../Src/MPU6050/mllite/: data_builder.c hal_outputs.c message_layer.c mlmath.c ml_math_func.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../Src/MPU6050/mpl/: libmpllib.lib
  group Application/User
    ../Src/: tim.c main.c i2c.c usart.c stm32f0xx_it.c stm32f0xx_hal_msp.c gpio.c EXTI_PD2_IRQHandler.c self-balancing-robot_main_Init.c EXTI_USART1_BT.c dma.c
    ../Src/printf_&_scanf_override_HAL/: override_printf_&_scanf.c
    ../Src/Encoder/: Encoder.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f0xx.c
software components: CMSIS:CORE 4.3.0
